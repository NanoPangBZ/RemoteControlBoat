# Keil uVision project RemoteControl.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RemoteControl
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\USER;..\StdPeriph\inc;..\OS\core\include;..\OS\port;C:\Keil_v5\ARM\PACK\Keil\STM32F1xx_DFP\2.3.0\Device\Include;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.8.0\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c self_stm32f10x.c stm32f10x_it.c FreeRTOSConfig.h isr.c
  group StdPeriph
    ../StdPeriph/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group BSP
    ../USER/BSP/: bsp_adc.c bsp_spi.c bsp_usart.c
  group HARDWARE
    ../USER/HARDWARE/: nrf24l01.c usart_hmi.c
  group SOFTWARE
    ../USER/SOFTWARE/: user.c remote.c
  group freeRTOS/core
    ../OS/core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freeRTOS/port
    ../OS/port/: port.c
    ../OS/port/MemMang/: heap_4.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
