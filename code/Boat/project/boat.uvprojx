# Keil uVision project boat.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: boat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: C:\Keil_v5\ARM\PACK\Keil\STM32F1xx_DFP\2.3.0\Device\Include;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.8.0\CMSIS\Core\Include;..\FWLIB\inc;..\USER;..\OS\include;..\OS\portable;..\..\..\code
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ../USER/: main.c user.c isr.c self_stm32f10x.c stm32f10x_it.c FreeRTOSConfig.h
  group BSP
    ../USER/BSP/: bsp_pwm.c bsp_spi.c bsp_usart.c bsp_led.c bsp_timer.c bsp_key.c bsp_beep.c
  group HARDWARE
    ../USER/HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../USER/HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../USER/HARDWARE/NRF24/: nrf24l01.c
    ../USER/HARDWARE/OLED/: oled12864.c
    ../USER/HARDWARE/MOTOR/: a4950.c street_motor.c er.c
    ../USER/HARDWARE/: hardware_def.h
  group SOFTWARE
    ../USER/SOFTWARE/: vofa_p.c
    ../../self_portable/: self_portable.c
  group OS/core
    ../OS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group OS/port
    ../OS/portable/: heap_4.c port.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
